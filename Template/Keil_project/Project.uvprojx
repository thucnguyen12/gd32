# Keil uVision project Project.uvprojx, settings and files
target GD32E23x (6140000::V6.14::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_Commom;..\..\Firmware\GD32E23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32E23x\Include;..\lwrb;..\board_hw;..\min_protocol;..\app_mqtt_protocol;..\flash;..\u8g2;..\app_debug;..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: main.c gd32e23x_it.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Peripherals
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Utilities
    ../../Utilities/: gd32e230c_eval.c
  group Doc
    ../: readme.txt
  group board_hw
    ../board_hw/: board_hw.c board_hw.h
  group lwrb
    ../lwrb/: lwrb.c
    ../lwrb/include/lwrb/: lwrb.h
  group min
    ../min_protocol/: min.c min.h min_id.h
  group flash
    ../flash/: flash.c flash.h
  group u8g2
    ../u8g2/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_il3820_296x128.c u8x8_d_ist3020.c u8x8_d_ist7920.c u8x8_d_ks0108.c u8x8_d_lc7981.c u8x8_d_ld7032_60x32.c u8x8_d_ls013b7dh03.c u8x8_d_max7219.c u8x8_d_pcd8544_84x48.c u8x8_d_pcf8812.c u8x8_d_pcf8814_hx1230.c u8x8_d_s1d15e06.c u8x8_d_s1d15721.c u8x8_d_sbn1661.c u8x8_d_sed1330.c u8x8_d_sh1106_64x32.c u8x8_d_sh1106_72x40.c u8x8_d_sh1107.c u8x8_d_sh1108.c u8x8_d_sh1122.c u8x8_d_ssd1305.c u8x8_d_ssd1306_48x64.c u8x8_d_ssd1306_64x32.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1306_72x40.c u8x8_d_ssd1306_96x16.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1306_2040x16.c u8x8_d_ssd1309.c u8x8_d_ssd1316.c u8x8_d_ssd1317.c u8x8_d_ssd1318.c u8x8_d_ssd1320.c u8x8_d_ssd1322.c u8x8_d_ssd1325.c u8x8_d_ssd1326.c u8x8_d_ssd1327.c u8x8_d_ssd1329.c u8x8_d_ssd1606_172x72.c u8x8_d_ssd1607_200x200.c u8x8_d_st7511.c u8x8_d_st7528.c u8x8_d_st7565.c u8x8_d_st7567.c u8x8_d_st7571.c u8x8_d_st7586s_erc240160.c u8x8_d_st7586s_s028hn118a.c u8x8_d_st7586s_ymc240160.c u8x8_d_st7588.c u8x8_d_st7920.c u8x8_d_st75256.c u8x8_d_st75320.c u8x8_d_stdio.c u8x8_d_t6963.c u8x8_d_uc1601.c u8x8_d_uc1604.c u8x8_d_uc1608.c u8x8_d_uc1610.c u8x8_d_uc1611.c u8x8_d_uc1617.c u8x8_d_uc1638.c u8x8_d_uc1701_dogs102.c u8x8_d_uc1701_mini12864.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group app_debug
    ../app_debug/: app_debug.c app_debug.h
  group RTT_Segger
    ../RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.0.2
